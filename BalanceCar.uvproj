# Keil uVision project BalanceCar.uvproj, settings and files
target BalanceCar (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: BalanceCar
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Include
  group Source
    ./Source/: STARTUP.A51 main.c
  group Include
    ./Include/: config.h
